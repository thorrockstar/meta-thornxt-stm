
S = "${WORKDIR}/git"

PROJECTS_LIST_EV1 = " \
"

PROJECTS_LIST_DK2 = " \
"

PROJECTS_LIST = "${PROJECTS_LIST_EV1} ${PROJECTS_LIST_DK2}"
